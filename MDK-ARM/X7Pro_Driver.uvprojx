# Keil uVision project X7Pro_Driver.uvprojx, settings and files
target X7Pro_Driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: X7Pro_Driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../CODE;../CODE/application;../CODE/drivers;../CODE/drivers/barometer;../CODE/drivers/fram;../CODE/drivers/gps;../CODE/drivers/imu;../CODE/drivers/mag;../CODE/drivers/usbd;../CODE/hal/actuator;../CODE/hal/adc;../CODE/hal/barometer;../CODE/hal/can;../CODE/hal/dma;../CODE/hal/fmtio_dev;../CODE/hal/gps;../CODE/hal/imu;../CODE/hal/mag;../CODE/hal/rc;../CODE/hal/sd;../CODE/hal/serial;../CODE/hal/spi;../CODE/hal/systick;../CODE/hal/usb;../CODE/lib/libc;../CODE/lib/libc/armlibc;../CODE/lib/libc/armlibc/sys;../CODE/lib/mavlink/v2.0;../CODE/lib/mavlink/v2.0/fmt_mavlink;../CODE/lib/mavlink/v2.0/common;../CODE/model/ins;../CODE/model/ins/base_ins/lib;../CODE/model/fms;../CODE/model/fms/base_fms/lib;../CODE/model/control;../CODE/model/control/base_controller/lib;../CODE/module;../CODE/module/buzzer;../CODE/module/calibration;../CODE/module/console;../CODE/module/dfs/include;../CODE/module/dfs/filesystems/elmfat;../CODE/module/file_manager;../CODE/module/filter;../CODE/module/finsh;../CODE/module/fmtio;../CODE/module/ipc;../CODE/module/log;../CODE/module/math;../CODE/module/mavproxy;../CODE/module/param;../CODE/module/pmu;../CODE/module/sensor;../CODE/module/syscmd;../CODE/module/sysio;../CODE/module/system;../CODE/module/toml;../CODE/module/utils;../CODE/module/workqueue;../CODE/protocol/sbus;../CODE/protocol/ublox;../CODE/rtos;../CODE/rtos/completion;../UCOSIII/uC-CPU;../UCOSIII/uC-CPU/ARM-Cortex-M4/ARM;../UCOSIII/uC-LIB;../UCOSIII/UCOS-BSP;../UCOSIII/UCOS-CONFIG;../UCOSIII/uCOS-III/Source;../UCOSIII/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bdma.c dma.c fdcan.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_ll_gpio.c stm32h7xx_ll_bdma.c stm32h7xx_ll_dma.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_spi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group CODE
    ../CODE/: init.c
  group CODE/application
    ../CODE/application/: application.c app_comm.c app_io.c app_logger.c app_status.c app_vehicle.c
  group CODE/drivers
    ../CODE/drivers/: drv_adc.c drv_dma.c drv_exti.c drv_gpio.c drv_i2c_soft.c drv_spi.c drv_systick.c drv_uart.c io.c pwm.c timer.c board.c drv_buzzer.c drv_fdcan.c drv_pwm.c drv_rc.c drv_sdio.c rotate.c
    ../CODE/drivers/fram/: fm25vx.c fram.c
    ../CODE/drivers/imu/: adis16470.c icm20689.c icm42688.c
    ../CODE/drivers/mag/: rm3100.c
    ../CODE/drivers/barometer/: ms5611.c
    ../CODE/drivers/gps/: gps_ubx.c
    ../CODE/drivers/usbd/: drv_usbd_cdc.c
  group CODE/hal
    ../CODE/hal/adc/: adc.c
    ../CODE/hal/barometer/: barometer.c
    ../CODE/hal/dma/: dma.c
    ../CODE/hal/fmtio_dev/: fmtio_dev.c
    ../CODE/hal/gps/: gps.c
    ../CODE/hal/imu/: accel.c gyro.c
    ../CODE/hal/mag/: mag.c
    ../CODE/hal/rc/: ppm.c rc.c
    ../CODE/hal/sd/: sd.c
    ../CODE/hal/serial/: serial.c
    ../CODE/hal/spi/: spi.c
    ../CODE/hal/systick/: systick.c
    ../CODE/hal/actuator/: actuator.c
    ../CODE/hal/can/: can.c
    ../CODE/hal/usb/: usbd_cdc.c
  group CODE/lib
    ../CODE/lib/libc/armlibc/: mem_std.c stubs.c
  group CODE/model
    ../CODE/model/ins/base_ins/: ins_interface.c
    ../CODE/model/ins/base_ins/lib/: INS.c
    ../CODE/model/fms/base_fms/: fms_interface.c
    ../CODE/model/fms/base_fms/lib/: FMS.c FMS_data.c
    ../CODE/model/control/base_controller/: control_interface.c
    ../CODE/model/control/base_controller/lib/: Controller.c Controller_data.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
    ../Middlewares/ST/ARM/DSP/lib/: arm_cortexM4lf_math.lib
  group CODE/module
    ../CODE/module/buzzer/: buzzer_tune.c decode.c player.c
    ../CODE/module/calibration/: calibration.c calibration_param.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
    ../CODE/module/console/: console.c console_config.c
    ../CODE/module/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../CODE/module/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../CODE/module/file_manager/: file_ex_ops.c file_manager.c yxml.c
    ../CODE/module/filter/: butter.c
    ../CODE/module/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
    ../CODE/module/fmtio/: fmtio.c fmtio_uploader.c protocol.c
    ../CODE/module/ipc/: ringblk_buf.c uMCN.c
    ../CODE/module/log/: boot_log.c logger.c mlog.c ulog.c
    ../CODE/module/math/: ap_math.c conversion.c light_matrix.c quaternion.c rotation.c
    ../CODE/module/mavproxy/: mavlink_console.c mavlink_mission.c mavlink_param.c mavlink_status.c mavproxy.c mavproxy_cmd.c mavproxy_config.c mavproxy_dev.c mavproxy_monitor.c
    ../CODE/module/param/: param.c rc_param.c sys_param.c
    ../CODE/module/pmu/: power_manage.c
    ../CODE/module/sensor/: sensor_baro.c sensor_gps.c sensor_hub.c sensor_imu.c sensor_mag.c
    ../CODE/module/syscmd/: bsp_cmd.c cmd_boot_log.c cmd_mcn.c cmd_mlog.c cmd_param.c optparse.c syscmd.c
    ../CODE/module/sysio/: actuator_cmd.c actuator_config.c auto_cmd.c gcs_cmd.c mission_data.c pilot_cmd.c pilot_cmd_config.c
    ../CODE/module/system/: statistic.c systime.c
    ../CODE/module/toml/: toml.c toml_util.c
    ../CODE/module/utils/: devmq.c ringbuffer.c
    ../CODE/module/workqueue/: work_queue.c workqueue_manager.c
  group CODE/protocol
    ../CODE/protocol/sbus/: sbus.c
    ../CODE/protocol/ublox/: ublox.c
  group CODE/rtos
    ../CODE/rtos/: device.c event.c kservice.c mem.c mq.c mutex.c object.c os_common.c semaphore.c thread.c timer.c
    ../CODE/rtos/completion/: completion.c
  group UCOSIII/uC-CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/: cpu_c.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/ARM/: cpu_a.asm
  group UCOSIII/uC-LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group UCOSIII/UCOS-BSP
    ../UCOSIII/UCOS-BSP/: bsp_clk.c bsp_cpu.c bsp_int_armv7m.c bsp_os.c
  group UCOSIII/UCOS-CONFIG
    ../UCOSIII/UCOS-CONFIG/: os_app_hooks.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII/uCOS-III
    ../UCOSIII/uCOS-III/Source/: __dbg_uCOS-III.c os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
software components: CMSIS:CORE 5.6.0
